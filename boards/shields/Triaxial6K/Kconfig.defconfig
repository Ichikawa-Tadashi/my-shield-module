## boards/shields/Triaxial6K/Kconfig.defconfig
```kconfig
if SHIELD_TRIAXIAL6K

# Name must be less than 16 characters long!
config ZMK_KEYBOARD_NAME
    default "Triaxial6K"

endif
```
